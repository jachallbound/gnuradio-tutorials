options:
  parameters:
    author: jachall
    generate_options: qt_gui
    id: sampleRateChange
    output_language: python
    title: Sample Rate Change
  states: {}

blocks:
- name: decimation_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '-samp_rate/2'
    step: '500'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: lowPassTaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_interpolated/(interpolation_rate*2)
    gain: '1.0'
    samp_rate: samp_rate_interpolated
    width: samp_rate_interpolated/(interpolation_rate*4)
    win: window.WIN_HAMMING
  states: {}
- name: lowPassTaps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_decimated/2
    gain: '1.0'
    samp_rate: samp_rate_decimated
    width: samp_rate_decimated/4
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_decimated
  id: variable
  parameters:
    value: samp_rate/decimation_rate
  states: {}
- name: samp_rate_interpolated
  id: variable
  parameters:
    value: samp_rate*interpolation_rate
  states: {}
- name: PassBandNoise_0
  id: PassBandNoise
  parameters:
    bandwidth: samp_rate/8
    frequency: frequency
    samp_rate: samp_rate
  states: {}
- name: PassBandNoise_0_0
  id: PassBandNoise
  parameters:
    bandwidth: '500'
    frequency: frequency
    samp_rate: samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_interpolated
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_decimated
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: |-
      Input Samp Rate: 32 kHz
      Output Samp Rate: 8 kHz
    decim: decimation_rate
    taps: lowPassTaps_0
    type: fcc
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: |-
      Input Samp Rate: 32 kHz
      Output Samp Rate 128 kHz
    interp: interpolation_rate
    taps: lowPassTaps
    type: fcc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_interpolated
    fc: '0'
    fftsize: '1024'
    name: Interpolated Signal
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_decimated
    fc: '0'
    fftsize: '1024'
    name: Decimated Signal
    type: complex
  states: {}

connections:
- [PassBandNoise_0, '0', interp_fir_filter_xxx_0, '0']
- [PassBandNoise_0_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [fir_filter_xxx_0, '0', blocks_throttle_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
