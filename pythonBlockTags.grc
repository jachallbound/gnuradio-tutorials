options:
  parameters:
    author: jachall
    generate_options: qt_gui
    id: pythonBlockTags
    output_language: python
    title: Python Block Tags
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3200'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '128'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: '32'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, threshold = 1.0, report_period=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Threshold Detector',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.threshold = threshold
              self.report_period = report_period

              self.timer = 0
              self.readyForTag = True

          def work(self, input_items, output_items):
              "Search for samples above threshold"
              for index in range(len(input_items[0])):
                  # We found detected a value above threshold, set the Tag
                  if (input_items[0][index] >= self.threshold and self.readyForTag == True):
                      key = pmt.intern("detect")
                      value = pmt.from_float(np.round(float(input_items[0][index]), 2))
                      writeIndex = self.nitems_written(0) + index
                      self.add_item_tag(0, writeIndex, key, value)
                      self.readyForTag = False
                  # Increment timer after Tag has been set
                  if (self.readyForTag == False):
                      self.timer += 1
                  # Once timer is finished, we are ready to detect again
                  if(self.timer >= self.report_period):
                      self.timer = 0
                      self.readyForTag = True

              output_items[0][:] = input_items[0]
              return len(output_items[0])
    report_period: '128'
    threshold: '0.75'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Detection Counter',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.samplesSinceDetection = 0


          def work(self, input_items, output_items):
              # Counter number of detections

              # Get all tags from input_items
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))
              relativeOffsetList = []

              # Get relative offsets of all 'detect' tags
              for tag in tagTuple:
                  if (pmt.to_python(tag.key) == 'detect'):
                      relativeOffsetList.append(tag.offset - self.nitems_read(0))
              relativeOffsetList.sort()

              # Loop through all output samples
              for index in range(len(output_items[0])):
                  output_items[0][index] = self.samplesSinceDetection

                  if (len(relativeOffsetList) > 0 and index >= relativeOffsetList[0]):
                      relativeOffsetList.pop(0)
                      self.samplesSinceDetection = 0
                  else:
                      self.samplesSinceDetection += 1

              return len(output_items[0])
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: Detection Counter
    size: '2048'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: Threshold Detector
    size: '2048'
    srate: samp_rate
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.05'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [digital_glfsr_source_x_0, '0', blocks_repeat_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0, '0']
- [single_pole_iir_filter_xx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
